DESCRIPTION = "USST groundstation system"
LICENSE = "MIT"

require recipes-core/images/core-image-minimal.bb
require common.inc
